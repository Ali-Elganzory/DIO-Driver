# IAR project playground.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: D:\Uni\Senior 1\Semester 1 - Fall 2021\CSE 211 - Introduction to Embedded Systems\Project\Embedded-C\DIO-Driver
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkAdditionalLibs: D:\Uni\Senior 1\Semester 1 - Fall 2021\CSE 211 - Introduction to Embedded Systems\Project\Embedded-C\DIO-Driver\Debug\Obj\DIO.o
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: lab4_p_task1.c lab4_p_task2.c lab4_task2.c main.c
